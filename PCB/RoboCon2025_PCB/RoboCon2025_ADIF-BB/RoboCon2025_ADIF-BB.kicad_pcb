# Repository C9bota/RoboCon2025

File README.md:

# RoboCon2025
週10で松屋 チームの作品用リポジトリです

キャリブレーション用サイト
https://personal.qumcum.com/robo_adjust/

## フォルダ構成
Arduino IDEは、スケッチフォルダ直下にあるファイルおよび、srcフォルダの中をコンパイル対象とするため、以下のようなフォルダ構成とする。
各ライブラリは機能ごとにフォルダを分け、src配下へ置くこと。

```
RoboCon2025/
├── README.md             
├── Production/            # 本番用コード
│   └── qumcum_fes_2025/   # スケッチフォルダ
│       ├── qumcum_fes_2025.ino   # エントリポイント
│       └── src/
│           ├── core/      
│           ├── midi/      # MIDI読み込み
│           ├── sd/        # 
│           └── servo/     # サーボ駆動ライブラリ
│               ├── lib/
│               └── src/
│
├── Prototype/             # プロトタイプ開発
│   ├── Common/            # 共通ライブラリ・ユーティリティ
│   │   └── midifiles      # MIDIファイル
│   ├── Kubota/           
│   ├── Masuda/           
│   └── Nakagawa/          
|
└── Samples/               # Qumcum公式サンプルコード
    ├── Aquestalk.cpp
    ├── Beep.cpp
    ├── RGB.cpp
    └── Servo.cpp

```

- **Production/**: 本番環境で使用する最終的なコード
- **Prototype/**: 開発中のプロトタイプコード
  - **Common/**: 各プロトタイプで共通して使用するライブラリやユーティリティ
  - **Kubota/**: 久保田のプロトタイプ実装
  - **Masuda/**: 増田のプロトタイプ実装
  - **Nakagawa/**: 中川のプロトタイプ実装
- **Samples/**: 実験用のサンプルコードやテストコード
  - [`Aquestalk.cpp`](Samples/Aquestalk.cpp): AquesTalkを使用した音声合成のサンプル
  - [`Beep.cpp`](Samples/Beep.cpp): PWMを使用したビープ音出力のサンプル
  - [`RGB.cpp`](Samples/RGB.cpp): RGB LEDの制御サンプル

## KiCad design PCB/RoboCon2025_PCB/RoboCon2025_ADIF-BB/RoboCon2025_ADIF-BB.kicad_pcb

Parts:
C2, C3, C4, C7, C8: 0.1u 50V; C_Disc_D3.0mm_W2.0mm_P2.50mm
C5, C6: 2.2u 50V; C_Disc_D7.0mm_W2.5mm_P5.00mm
C9, C10: 2200p 50V; C_Disc_D7.0mm_W2.5mm_P5.00mm
D1, D2: SS14; D_A-405_P7.62mm_Horizontal
J1: Conn_01x05; PinHeader_1x05_P2.54mm_Vertical
J2, J3: Conn_01x09; PinHeader_1x09_P2.54mm_Vertical
J4, J7, J8: S2B-XH-A; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J6, J9: S3B-XH-A; JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal
JP1: Normally Connected; SolderJumper-2_P1.3mm_Bridged2Bar_Pad1.0x1.5mm
R6, R9: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R7, R8: 470; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
U1: PCM5102A; DIP-24_W15.24mm_Socket
U3: TBD62083AFNG; DIP-18_W7.62mm_Socket
U4: MCP23017_SP; DIP-28_W7.62mm_Socket

Connections:
+3V3: C2.1, C3.1, C4.1, C8.2, D1.1 (K), J1.1, J3.1, J9.1, R6.2, R9.1, U1.1 (CPVDD), U1.8 (AVDD), U1.17 (XSMT), U1.20 (DVDD), U4.9 (VDD)
/AUDIO_OUT_L: C9.1, J6.2, R7.2
/AUDIO_OUT_R: C10.1, J6.3, R8.2
/EXT_3SCL: J2.5, U4.12 (SCK)
/EXT_3SDA: J2.6, U4.13 (SDA)
/I2S_BCLK: J1.3, U1.13 (BCK)
/I2S_DIN: J1.4, U1.14 (DIN)
/I2S_LRCK: J1.5, U1.15 (LRCK)
ACT_N: D1.2 (A), D2.1 (K), J4.2, R9.2, U4.24 (GPA3)
GND: C4.2, C7.2, C8.1, D2.2 (A), J1.2, J2.1, J3.9, J4.1, J7.2, J8.2, JP1.1 (A), U1.10 (DEMP), U1.11 (FLT), U1.12 (SCK), U1.16 (FMT), U1.19 (DGND), U3.1 (I1), U3.2 (I2), U3.3 (I3), U3.4 (I4), U3.9 (GND), U4.7 (GPB6), U4.10 (VSS), U4.15 (A0), U4.16 (A1), U4.17 (A2)
GNDA: C2.2, C3.2, C5.2, C9.2, C10.2, J6.1, JP1.2 (B), U1.3 (CPGND), U1.9 (AGND)
unnamed: J7.1, U3.14 (O5)
unnamed: J8.1, U3.13 (O6)
unnamed: J9.2, U3.11 (O8)
unnamed: J9.3, U3.12 (O7)
unnamed: C6.1, U1.4 (CAPM)
unnamed: C6.2, U1.2 (CAPP)
unnamed: C7.1, U1.18 (LDOO)
unnamed: R7.1, U1.6 (OUTL)
unnamed: R8.1, U1.7 (OUTR)
unnamed: C5.1, U1.5 (VNEG)
unnamed: U3.5 (I5), U4.25 (GPA4)
unnamed: U3.6 (I6), U4.26 (GPA5)
unnamed: U3.7 (I7), U4.28 (GPA7)
unnamed: U3.8 (I8), U4.27 (GPA6)
unnamed: R6.1, U4.18 (~RESET)

Notes on the sheet:
SCKは内蔵PLLで生成
I2C Slv Addr=0x20
PerformerのADIF基板へ 電流吸い込み
Conductor: 外部SWから Performer: ADIF基板から
I2CはR321Jメインボードでプルアップ済み
Stereo OUT
SOLDER基板へ 電流吸い込み

Board: 2 copper layers, 27 parts (4 on the bottom side), 26 nets.

## KiCad design PCB/RoboCon2025_PCB/RoboCon2025_ADIF-BB-P/RoboCon2025_ADIF-BB-P.kicad_pcb

Parts:
C1: 0.1u 50V; C_Disc_D3.0mm_W2.0mm_P2.50mm
D1, D2: SS14; D_DO-15_P2.54mm_Vertical_AnodeUp
J1: Conn_01x05; PinHeader_1x05_P2.54mm_Vertical
J2, J3: Conn_01x09; PinHeader_1x09_P2.54mm_Vertical
J4: S2B-XH-A; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J5: S3B-XH-A; JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal
R1: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R2: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
U1: MCP23017_SP; DIP-28_W7.62mm_Socket
U2: TBD62083AFNG; DIP-18_W7.62mm_Socket

Connections:
+3V3: C1.2, D1.1 (K), J1.1, J3.1, J5.1, R1.2, R2.1, U1.9 (VDD)
/EXT_3SCL: J2.5, U1.12 (SCK)
/EXT_3SDA: J2.6, U1.13 (SDA)
ACT_N: D1.2 (A), D2.1 (K), J4.2, R2.2, U1.27 (GPA6)
GND: C1.1, D2.2 (A), J1.2, J4.1, U1.10 (VSS), U1.15 (A0), U1.16 (A1), U1.17 (A2), U2.3 (I3), U2.4 (I4), U2.5 (I5), U2.6 (I6), U2.7 (I7), U2.8 (I8), U2.9 (GND)
unnamed: J5.2, U2.17 (O2)
unnamed: J5.3, U2.18 (O1)
unnamed: U1.25 (GPA4), U2.2 (I2)
unnamed: U1.26 (GPA5), U2.1 (I1)
unnamed: R1.1, U1.18 (~RESET)

Notes on the sheet:
I2C Slv Addr=0x20
Conductor: 外部SWから Performer: ADIF基板から
I2CはR321Jメインボードでプルアップ済み
SOLDER基板へ 電流吸い込み

Board: 2 copper layers, 47.0 x 72.0 mm, 12 parts (3 on the bottom side), 10 nets.

## KiCad design PCB/RoboCon2025_PCB/RoboCon2025_SOLDR/RoboCon2025_SOLDR.kicad_pcb

Parts:
C1: 0.33u 50V; C_Disc_D5.0mm_W2.5mm_P5.00mm
C2: 0.1u 50V; C_Disc_D5.0mm_W2.5mm_P5.00mm
D1, D2: PG2010; D_DO-27_P15.24mm_Horizontal
J1: B3B-XH-A; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J2: Barrel_Jack_Switch; BarrelJack_Horizontal
J3, J4: TB112-2-2-E-1; TerminalBlock_bornier-2_P5.08mm
JP1: Jumper_3_Open; PinHeader_1x03_P2.54mm_Vertical
Q1, Q2: 2SK4017; TO-220-3_Vertical
R1, R2: 120; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3, R4: 330; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R5, R6: 820; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SW1, SW2: SW_Push; SW_PUSH_6mm_H5mm
U1, U2: TLP785(GB F); DIP-4_W7.62mm
U3: L78L05_TO92; TO-92_Inline_Wide

Connections:
+3V3: J1.1, R1.1, R2.1
+5V: C2.1, JP1.2 (C), U3.1 (VO)
GNDPWR: C1.2, C2.2, J2.2, J2.3, Q1.3 (S), Q2.3 (S), R3.2, R4.2, U3.2 (GND)
unnamed: D1.2 (A), J3.2, Q1.2 (D)
unnamed: D2.2 (A), J4.2, Q2.2 (D)
unnamed: J1.2, U1.2
unnamed: J1.3, U2.2
unnamed: JP1.1 (A), U1.4, U2.4
unnamed: JP1.3 (B), SW1.1, SW2.1
unnamed: Q1.1 (G), R5.2
unnamed: Q2.1 (G), R6.2
unnamed: R1.2, U1.1
unnamed: R2.2, U2.1
unnamed: R3.1, R5.1, SW1.2, U1.3
unnamed: R4.1, R6.1, SW2.2, U2.3
VDD: C1.1, D1.1 (K), D2.1 (K), J2.1, J3.1, J4.1, U3.3 (VI)

Notes on the sheet:
6-24V

Board: 2 copper layers, 82.0 x 48.5 mm, 22 parts (0 on the bottom side), 16 nets.

## Commit log

2025-10-23 フォルダ構成を編集
2025-10-23 Readmeにフォルダ構成を追記
2025-10-23 add サンプルコード
2025-10-23 フォルダ構成を修正
2025-10-26 PIN IOを定数化した
2025-10-26 サーボモーターのチャネルを列挙型で定義
2025-10-26 コマンド番号の定義を追加
2025-10-26 コマンドとバッファサイズの対応表を作成
2025-10-26 インターフェースを仮置き
2025-10-26 インターフェースを定義
2025-10-26 各インターフェースの処理をAI実装
2025-11-05 create directory for PCB project
2025-11-05 initial commit of KiCad project
2025-11-05 initial commit of KiCad SOLDR board project
2025-11-06 [PCB] SOLDR基板の配線完了。駆動能力不足懸念のため、フォトカプラ発光側にTr増幅回路挿入予定。
2025-11-08 <Wire.h>の呼び出し処理を修正
2025-11-08 includeからlibに変更
2025-11-08 テストビルドが通るように修正
2025-11-08 モーターのテストを修正
2025-11-08 サーボ動作用ライブラリをProductionに追加
2025-11-16 add: SOLDR基板配置・配線図
2025-11-16 [PCB] add: ADIF schematic and layout
2025-11-24 ADIF 編集
2025-11-24 MD_MIDIFILEライブラリを追加
2025-11-24 各イベントのデータモデルを定義
2025-11-24 ノートオンイベントを受け取るインターフェースを実装
2025-11-24 MIDIを動作に変換する実装を作成
2025-11-24 左腕サーボの定数名を正しいものに修正
2025-11-24 メタイベントのインターフェースを定義
2025-11-24 初期化メタイベントのインターフェースを実装
2025-11-24 初期化イベント処理を修正
2025-11-25 [PCB] ADIF基板のIOエキスパンダ部品変更
2025-11-29 サンプル用のmidiファイルを追加
2025-11-29 不要となったgitkeepの削除
2025-11-29 本番環境の構成用にディレクトリを整理＆ピン定義を追加
2025-11-29 構成の変更及びreadmeの更新
2025-11-30 SDを使うプロトタイプを追加
2025-11-30 IOエキスパンダサンプル
2025-12-06 MIDI変換インターフェースのインクルードを修正
2025-12-06 動作時間と角度を調整
2025-12-06 インクルードディレクトリを修正修正
2025-12-06 不要な改行を削除
2025-12-07 [PCB] add: ADIF基板分割
2025-12-07 コンパイルが通るように修正
2025-12-07 角度を正しい表記に修正
2025-12-07 MIDIインターフェースのテストを実施
2025-12-07 MIDIインターフェースの製品版を配置
2025-12-07 MIDIFILEライブラリを削除
2025-12-08 ノート番号に応じて挙動を変えるように変更
2025-12-08 デフォルト動作を定義
2025-12-08 動作を確認
2025-12-08 ノートオンイベントの頻度コメントを修正
2025-12-08 複数楽器対応のMIDI変換インターフェース実装をProductに配置
2025-12-08 [PCB] update: BB基板のパターン引いた(未配線あり)
2025-12-08 MIDIMIDI読み込み～サーボ動作までの処理を仮実装
2025-12-08 [PCB] update: 配線完了！
2025-12-09 [SD-WAV] fix: ピン配置
2025-12-09 [EXIO] add: ライブラリ化できる構成をプロトタイプに追加
2025-12-09 [EXIO] add: IOエキスパンダ入出力のドライバを本番環境に追加
2025-12-10 test.midを追加
2025-12-10 servo_move.hを配置
2025-12-10 SDカードの存在確認とファイルの存在確認を実施する処理を追加
2025-12-10 SDカード読み込み、ファイル確認、MD_MIDIFile読み込み処理を実装
2025-12-10 ノートオンイベントの検知
2025-12-10 読み込み処理までは完了
2025-12-10 MIDIから動作への変換を実装
2025-12-11 exioを追加
2025-12-11 exioライブラリを呼び出してソレノイドを動作する処理を追加
2025-12-11 ソレノイドの初期化処理を追加
2025-12-11 ノート番号出力追加
2025-12-12 LED関連の処理をコメントアウト
2025-12-12 サーボモーター処理に変更
2025-12-12 右腕も実装
2025-12-12 右手の回転角を調整
2025-12-12 角度調整
